# Keil uVision project test01.uvprojx, settings and files
target test01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test01
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52 NRF52832
  c include: ..\source;..\source\user;..\source\bsp;..\source\bsp;..\source\components\drivers_nrf\hal;..\source\components\libraries\util;..\source\components\drivers_nrf\nrf_soc_nosd;..\source\components\libraries\uart;..\source\components\drivers_nrf\uart;..\source\components\libraries\fifo;..\source\components\drivers_nrf\uart;..\source\components\device;..\source\components\libraries\log;..\source\components\libraries\log\src;..\source\components\drivers_nrf\common;..\source\components\drivers_nrf\twi_master\deprecated;..\source\components\drivers_nrf\twi_master\deprecated\config;..\source\components\drivers_nrf\delay
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ../source/bsp/: user_board.c
  group usr
    ../source/user/: main.c test_config.c user_gpio.c user_uart.c user_iic.c
    ../source/components/libraries/uart/: retarget.c app_uart_fifo.c
    ../source/components/libraries/util/: app_error.c app_error_weak.c
    ../source/components/libraries/fifo/: app_fifo.c
    ../source/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../source/components/drivers_nrf/common/: nrf_drv_common.c
    ../source/components/drivers_nrf/twi_master/deprecated/: twi_hw_master.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
